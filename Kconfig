## Kconfig
```kconfig
config SECURITY_BMSTU
bool "BMSTU security module"
      	default y
help
      	Any help text here
```
